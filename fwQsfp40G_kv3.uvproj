# Keil uVision project fwQsfp40G_kv3.uvproj, settings and files
target fwQsfp40G_KV3 (ARM-ADS)
  device: ADuC7020 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: qsfp40glr +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group startup
    ./: irq_arm.c ADuC702x.s
  group app
    ./code/: main.c init.c inttrupt.c flash.c i2cbg.c misc.c
  group inc
    ./code/: ADuC7023.h pubcom.h pubtype.h
    ./: ADuC7020.h
